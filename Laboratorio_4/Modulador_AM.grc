options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Modulador_AM
    output_language: python
    title: Modulador_AM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Apmlitud Mensaje
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la Portadora
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '100e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la Portadora
    start: '50'
    step: '100e-3'
    stop: 2.2e3
    value: '50'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente ka
    start: '0'
    step: '10e-3'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: BloqueModuladorAM_0
  id: BloqueModuladorAM
  parameters:
    Ac: Ac
    ka: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1E6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [BloqueModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [BloqueModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [BloqueModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', BloqueModuladorAM_0, '0']

metadata:
  file_format: 1
