options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: PARTE_ENTERA_J1B_G5
    output_language: python
    title: PARTE_ENTERA
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '320000'
  states: {}
- name: Modulos_J1B_ParteEnteraJ1B_0
  id: Modulos_J1B_ParteEnteraJ1B
  parameters:
    PARAM1: 'True'
    PARAM2: samp_rate
  states: {}
- name: Modulos_J1B_ParteEnteraJ1B_0_0
  id: Modulos_J1B_ParteEnteraJ1B
  parameters:
    PARAM1: 'False'
    PARAM2: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [Modulos_J1B_ParteEnteraJ1B_0, '0', qtgui_time_sink_x_0, '0']
- [Modulos_J1B_ParteEnteraJ1B_0_0, '0', qtgui_time_sink_x_0, '1']
- [analog_sig_source_x_0, '0', Modulos_J1B_ParteEnteraJ1B_0, '0']
- [analog_sig_source_x_0, '0', Modulos_J1B_ParteEnteraJ1B_0_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
