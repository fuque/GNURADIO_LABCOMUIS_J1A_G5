options:
  parameters:
    author: labcom
    generate_options: qt_gui
    id: Transmisor_AM
    output_language: python
    title: Transmisor_AM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Apmlitud Señal Modulante
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la Portadora
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '100e-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de la Portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: 5e3
    step: 1e3
    stop: 2.2e5
    value: 5e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: CalculoPotencia_0
  id: CalculoPotencia
  parameters:
    l_vect: '1024'
  states: {}
- name: EnvolventeComplejaSSB_0
  id: EnvolventeComplejaSSB
  parameters:
    Ac: Ac
    K: K
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeComplejaSSB_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeComplejaSSB_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeComplejaSSB_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', CalculoPotencia_0, '0']
- [analog_sig_source_x_0, '0', EnvolventeComplejaSSB_0, '0']

metadata:
  file_format: 1
